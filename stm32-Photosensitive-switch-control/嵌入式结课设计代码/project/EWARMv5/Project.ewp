# IAR project Project.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\; ..\..\library\inc; ..\..\library\src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: STM3210E-EVAL.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: ..\; ..\..\library\inc
  ILINK.IlinkOutputFile: STM3210B-EVAL.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  group Doc
    ./: readme.txt
  group EWARMv5
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../: main.c stm32f10x_it.c
